# Keil uVision project gc_hpgpLx51-frameTask -ASIC.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HYBRII_ETH, HPGP_MAC_SAP,NMA, HYBRII_SPI,NEW_SYNC,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,B_ASICPLC,UART_HOST_INTF_,UART_RAW,MPER_,FREQ_DETECT,SW_RECOVERY,BCN_ERR,KEEP_ALIVE,SPI_LOG,MCCO,MFG_PROFILE,AKM
  c misc: NOAREGS
  c include: ..\..\..\common\datapath;..\..\..\common\include;..\..\..\hal;..\..\src\crypto;..\..\src\ctrl;..\..\src\hal;..\..\src\link;..\..\src\mux;..\..\src\nma;..\..\src\route;..\..\src\test;..\..\..\project\hal\src;..\..\..\zigbee;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\common;..\..\..\hpgp;..\..\src;..\..\..\HybriiB_configuration_rw\src;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\osal\inc;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\nma;..\..\..\..\components\utilities;..\..\..\..\components\drivers\uart\inc;..\..\..\..\components\utilities\debug\inc;..\..\..\..\components\utilities\debug\inc;..\..\..\..\components\utilities\memory\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../project/hal/src/: clear_char.A51
    ../../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../../hal/: hal_common.c gv701x_uartdriver.c
    ../../src/: green.c
    ../../../common/: interrupt.c
  group Bank 0
    ../../../common/: stm.c list.c uart.c dmm.c event.c
    ../../../hal/: hal_hpgpRx.c
    ../../src/: hpgpctrl.c
    ../../../../components/utilities/debug/src/: fm.c
  group Bank 1
    ../../../project/hal/src/: hhal_led.c
    ../../../hal/: hal_eth.c hal_hpgp.c hal_spi.c
    ../../../common/: sys_common.c
    ../../src/route/: hpgp_route.c
  group Bank 2
    ../../../hal/: hal_hpgpTx.c
    ../../../common/datapath/: datapath.c FrameTask.c
  group Bank 3
    ../../../common/: ism.c
    ../../src/link/: crm.c linkl.c nsm_cco.c
  group Bank 4
    ../../src/ctrl/: ctrll.c
    ../../src/link/: nsm_sta.c
    ../../src/nma/: nma.c
    ../../src/mux/: muxl.c
  group Bank 5
    ../../src/link/: nam.c
    ../../src/test/: htm.c
    ../../src/hal/: hal.c
    ../../../common/: ui_utils.c sys_config.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 6
    ../../../common/: utils.c gv701x_flash.c
    ../../src/crypto/: aes.c crc32.c
    ../../src/link/: hom.c akm.c psm.c
    ../../../project/hal/src/: hal_hpgp_reset.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
